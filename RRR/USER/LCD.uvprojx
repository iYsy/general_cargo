# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\DEBUG;..\HARDWARE\USART;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
    ./uart/: bsp_uart.c bsp_uart.h
    ../HARDWARE/LCD/: picture.c picture.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd_init.c lcd.c
    ../HARDWARE/DEBUG/: debug.c debug.h
    ../HARDWARE/USART/: devices_usart01_debug.c devices_usart01_debug.h devices_usart02_zigbee.c devices_usart02_zigbee.h
    ../HARDWARE/: agreement.c agreement.h function.c function.h config.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c system_delay.c system_delay.h system_option.c system_option.h
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
